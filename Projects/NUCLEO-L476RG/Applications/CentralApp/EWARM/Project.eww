<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CentralApp.ewp</path>
  </project>
  <batchBuild />
</workspace>
